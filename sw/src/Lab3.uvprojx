# Keil uVision project Lab3.uvprojx, settings and files
target Lab3 (6220000::V6.22::ARMCLANG)
  device: LM4F120H5QR Texas Instruments
  pack: Keil.LM4F_DFP.1.0.0
  cpu: IRAM(0x10000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab3
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  group Source
    ./: startup.s Lab3Main.c display.c LaunchPad.c speaker.c switches.c SysTick.c time.c Timer1A.c Timer2A.c UART.c
    ../inc/: PLL.c Timer0A.c ST7735.c
software components: CMSIS:CORE 6.1.0
